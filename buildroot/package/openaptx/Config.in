## buildroot/package/openaptx/Config.in
```kconfig
config BR2_PACKAGE_OPENAPTX
	bool "openaptx"
	help
	  [open]aptx - reverse-engineered apt-X

          https://github.com/Arkq/openaptx
```
